# Keil uVision project STC8A8K64D4.uvproj, settings and files
target STC8A8K64D4 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STC8A8KD64 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\libraries;..\libraries\CoreSupport;..\libraries\CoreSupport\config;..\libraries\CoreSupport\config\stc8x;..\libraries\CoreSupport\startup;..\libraries\CoreSupport\startup\stc8x;..\libraries\DeviceSupport;..\libraries\DeviceSupport\stc8x\inc;..\libraries\DeviceSupport\stc8x\src;.\inc
  link misc: REMOVEUNUSED
  group lib/startup
    ../libraries/CoreSupport/startup/stc8x/: startup_stc8a.s
  group lib/core
    ../libraries/CoreSupport/: base_stc8x.h core_stc8x.h
  group lib/peripherals
    ../libraries/DeviceSupport/stc8x/src/: stc8x_adc.c stc8x_delay.c stc8x_eeprom.c stc8x_gpio.c stc8x_sysclk.c
  group user
    ./src/: ISR.asm main_ADC_BMM.c
  group hardware
    ./src/: uart.c fifo.c pca.c
